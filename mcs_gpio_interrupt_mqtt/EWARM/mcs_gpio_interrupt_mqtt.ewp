# IAR project mcs_gpio_interrupt_mqtt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_PING_OUT_ENABLE; PCFG_OS=2; _REENT_SMALL; MTK_MINISUPP_ENABLE; MTK_MINICLI_ENABLE; MTK_BSPEXT_ENABLE; MTK_HAL_LOWPOWER_ENABLE; MTK_LWIP_ENABLE; MTK_IPERF_ENABLE; PRODUCT_VERSION=7687; MTK_SMTCN_ENABLE; MTK_WIFI_REPEATER_ENABLE; CONFIG_REPEATER; configOVERRIDE_DEFAULT_TICK_CONFIGURATION; CFG_SUPPORT_SMNT_PROTO=2; MTK_WIFI_WPS_ENABLE; MTK_NVDM_ENABLE; MTK_FOTA_ON_7687; MTK_FOTA_ENABLE; MTK_DEBUG_LEVEL_NONE
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\rtos\FreeRTOS\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\wifi\inc; ..\..\..\..\..\middleware\third_party\dhcpd\inc; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\MTK\minisupp\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7687\src\common\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\project\mt7687_hdk\apps\mcs_gpio_interrupt_mqtt\inc; ..\..\..\..\..\driver\chip\mt7687\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\util\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\wifi\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\ept\inc; ..\..\..\..\..\driver\board\mt76x7_hdk\external_flash\inc; ..\..\..\..\..\middleware\third_party\httpclient\inc; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\mediatek; ..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\MTK\fota\inc; ..\..\..\..\..\middleware\MTK\fota\inc\76x7; ..\..\..\..\..\middleware\MTK\tftp\inc; ..\..\..\..\..\kernel\service\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: mcs_gpio_interrupt_mqtt.bin
  ILINK.IlinkOutputFile: mcs_gpio_interrupt_mqtt.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps
    ../src/: cli_cmds.c cli_def.c ept_eint_var.c ept_gpio_var.c main.c mcs.c mcs_mqtt.c mcs_tcp.c sys_init.c wifi_lwip_helper.c
  group bsp
    ../../../../../driver/board/mt76x7_hdk/util/src/: board_cli.c gpio_cli.c io_def.c
    ../../../../../driver/board/mt76x7_hdk/wifi/src/: get_profile_string.c misc.c os_util.c os_utils.c wifi_channel.c wifi_cli.c wifi_default_config.c wifi_inband_cli.c wifi_init.c wifi_os_api.c wifi_profile.c wifi_wps.c
    ../../../../../driver/board/mt76x7_hdk/lib/: libwifi_CM4_IAR.a
  group bspex
    ../../../../common/bsp_ex/src/: lp_ex_sleep.c wifi_ex_cli.c wifi_ex_config.c wifi_ex_connect.c wifi_ex_profile.c
    ../../../../../driver/board/mt76x7_hdk/wifi/src/: wifi_private_cli.c
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
  group dhcpd
    ../../../../../middleware/third_party/dhcpd/src/: dhcpd.c
  group driver
    ../../../../../driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../../../driver/chip/mt7687/src/sdio_gen3/: connsys_bus.c connsys_driver.c connsys_util.c
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_nvic.c hal_nvic_internal.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c
    ../../../../../driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group fota
    ../../../../../middleware/MTK/fota/src/: fota.c
    ../../../../../middleware/MTK/fota/src/76x7/: fota_76x7.c fota_cli.c fota_config.c fota_download_interface.c fota_port.c
  group gpio
    ../../../../../driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
  group httpclient
    ../../../../../middleware/third_party/httpclient/src/: httpclient.c
  group iarfs
    $EW_DIR$/arm/src/lib/: close.c lseek.c open.c read.c remove.c write.c
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_cli.c iperf_task.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7687/: port_tick.c
  group kservice
    ../../../../../kernel/service/lib/: libkservice_CM4_MT7687_IAR.a
    ../../../../../kernel/service/src/: memory_regions.c os_cli.c os_port_callback.c syslog_cli.c
  group lwip
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../../../../../middleware/third_party/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c pppcrypt.c pppoe.c pppos.c upap.c utils.c vj.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c udp.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c slipif.c
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
  group minicli
    ../../../../../middleware/MTK/minicli/lib/: libminicli_CM4_IAR.a
  group minisupp
    ../../../../../middleware/MTK/minisupp/lib/: libminisupp_wps_CM4_IAR.a
  group mqtt
    ../../../../../middleware/third_party/mqtt/MQTTClient-C/src/: MQTTClient.c
    ../../../../../middleware/third_party/mqtt/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
    ../../../../../middleware/third_party/mqtt/MQTTClient-C/src/mediatek/: MQTTMediatek.c
  group N9
    ../../../../../tools/iar/mt7687/N9/: mt76X7_n9_image.c
  group nvdm
    ../../../../../middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_port.c
  group ping
    ../../../../../middleware/third_party/ping/src/: ping.c ping_cli.c
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: elian.c smt_api.c smt_conn.c
    ../../../../../middleware/MTK/smtcn/lib/: libsmtcn_CM4_IAR.a
